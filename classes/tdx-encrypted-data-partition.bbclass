inherit tdx-tezi-data-partition

inherit tdx-encrypted
TDX_TEZI_DATA_PARTITION_MOUNTPOINT = "${TDX_ENC_STORAGE_MOUNTPOINT}"
