require recipes-security/optee/optee-ftpm-sec-features.inc
