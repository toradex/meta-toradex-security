require recipes-bsp/u-boot/u-boot-distro-boot-sec-features.inc
