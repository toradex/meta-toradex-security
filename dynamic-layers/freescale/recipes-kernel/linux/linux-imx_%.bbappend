require recipes-kernel/linux/linux-sec-features.inc
