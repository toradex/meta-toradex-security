require recipes-bsp/u-boot/u-boot-sec-features.inc
