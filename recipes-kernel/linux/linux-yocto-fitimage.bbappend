require recipes-kernel/linux/linux-fitimage-sec-features.inc
