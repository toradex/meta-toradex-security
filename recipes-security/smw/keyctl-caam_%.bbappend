EXTRA_OEMAKE += "KEYBLOB_LOCATION='${TDX_ENC_CAAM_KEYBLOB_DIR}'"
