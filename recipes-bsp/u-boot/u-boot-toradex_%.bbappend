require u-boot-sec-features.inc
